

EXTRA_PKGS:remove:omap-a15 = " \
    linalg-examples \
"

