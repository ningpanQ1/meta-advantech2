CONNECTIVITY_RDEPENDS:append:am335xepcr3220a1 = " \
    gadget-init \
"
