
UTILS:append:am335xrom3310a1 = " pru-adc-src"
UTILS:append:am335xrsb4220a1 = " pru-adc-src"
UTILS:append:am335xrsb4221a1 = " pru-adc-src"
UTILS:append:am335xepcr3220a1 = " pru-adc-src"


