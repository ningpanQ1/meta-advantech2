EXTRA_LIBS:append:am335xepcr3220a1 = " \
    pru-icss-dev \
    pru-icss-staticdev \
"
