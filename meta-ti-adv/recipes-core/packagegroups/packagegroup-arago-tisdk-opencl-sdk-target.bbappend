
UTILS:append:am57xxrom7510a1 = " tidl-examples-dev"
UTILS:append:am57xxrom7510a2 = " tidl-examples-dev"

