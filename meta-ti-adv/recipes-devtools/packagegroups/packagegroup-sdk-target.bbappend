
RDEPENDS:${PN}:remove = " \
   diffutils"


