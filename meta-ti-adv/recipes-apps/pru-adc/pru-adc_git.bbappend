
COMPATIBLE_MACHINE = "am335x-evm|am335xepcr3220a1"

