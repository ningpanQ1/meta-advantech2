
COMPATIBLE_MACHINE = "am335x-evm|am57xx-evm|am335xepcr3220a1"

